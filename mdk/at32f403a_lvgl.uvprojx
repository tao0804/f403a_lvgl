# Keil uVision project at32f403a_lvgl.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403ACGU7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.4
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f403a_lvgl
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\source\core\inc;..\source\mcu\inc;..\source\core\core_support;..\source\core\device_support;..\source\midware;..\source\driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group core
    ../source/core/src/: at32f403a_407_clock.c at32f403a_407_int.c main.c
    ../source/core/device_support/: system_at32f403a_407.c
    ./: startup_at32f403a_407.s
  group mcu
    ../source/mcu/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group driver
    ../source/driver/: lcd.c
  group midware
    ../source/midware/: at32f403a_407_board.c
